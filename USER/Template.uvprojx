# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: MM32SPIN27PS MindMotion
  pack: MindMotion.MM32SPIN2x_DFP.1.1.4
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00003000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CORE;..\HAL_lib\inc;..\Include;..\STARTUP;..\SRC;..\SRC\ssd1306;..\SRC\ili9163c;..\SRC\rotary_encoder;..\SRC\lvgl\examples\porting;..\SRC\lvgl;..\SRC\lvgl\src\lv_core;..\SRC\lvgl\src\lv_draw;..\SRC\lvgl\src\lv_font;..\SRC\lvgl\src\lv_gpu;..\SRC\lvgl\src\lv_hal;..\SRC\lvgl\src\lv_misc;..\SRC\lvgl\src\lv_themes;..\SRC\lvgl\src\lv_widgets;..\SRC\lvgl_app
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group src
    ../SRC/: main.c user_hal_lib.c user_hal.c user_hal_it.c user_hal_i2c.c user_hal_spi.c
    ../SRC/control_task/: control_task.c
    ../SRC/ssd1306/: ssd1306.c ssd1306_tests.c ssd1306_fonts.c
    ../SRC/ili9163c/: ili9163.c
    ../SRC/multi_button/: multi_button.c my_multi_button.c
  group algorithm
    ../SRC/: pid.c
  group HAL_lib
    ../HAL_lib/src/: HAL_adc.c HAL_comp.c HAL_crc.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_op.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group STARTUP
    ../STARTUP/: startup_MM32SPIN2xx_p.s system_MM32SPIN2xx_p.c
  group lvgl_port
    ../SRC/lvgl/examples/porting/: lv_port_disp.c
    ../SRC/lvgl/: lv_conf.h
  group lvgl
    ../SRC/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../SRC/lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../SRC/lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../SRC/lvgl/src/lv_gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.c lv_gpu_stm32_dma2d.c
    ../SRC/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../SRC/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../SRC/lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../SRC/lvgl/src/lv_widgets/: lv_win.c lv_tileview.c lv_textarea.c lv_tabview.c lv_table.c lv_switch.c lv_spinner.c lv_spinbox.c lv_slider.c lv_roller.c lv_page.c lv_objx_templ.c lv_objmask.c lv_msgbox.c lv_list.c lv_linemeter.c lv_line.c lv_led.c lv_label.c lv_keyboard.c lv_imgbtn.c lv_img.c lv_gauge.c lv_dropdown.c lv_cpicker.c lv_cont.c lv_checkbox.c lv_chart.c lv_canvas.c lv_calendar.c lv_btnmatrix.c lv_btn.c lv_bar.c lv_arc.c
  group lvgl_app
    ../SRC/lvgl_app/: lvgl_app.c
    ../SRC/lvgl/examples/porting/: lv_port_indev.c
